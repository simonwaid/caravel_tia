v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {user_analog_project_wrapper.sym} 60 -50 0 0 {name=x1}
